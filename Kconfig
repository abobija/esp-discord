## Kconfig
```kconfig
menu "Discord"

    config DISCORD_TOKEN
        string "Token"
        help
            Discord bot authentication token

endmenu
```
